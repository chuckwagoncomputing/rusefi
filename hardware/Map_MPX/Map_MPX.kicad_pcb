File: hardware/Map_MPX/Map_MPX.kicad_pcb (KiCad board)
At the start: 2 copper layers, 20.3 x 16.3 mm, 7 parts

Commit message: update pcb files
Other:
- net class Default removed
